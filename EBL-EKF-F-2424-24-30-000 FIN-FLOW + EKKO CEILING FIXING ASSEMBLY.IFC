Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Fin - Flow\EBL-EKF-F-2424-24-30-000 FIN-FLOW + EKKO CEILING FIXING ASSEMBLY.IFC
Time: 2024-12-18T17:24:06+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 161.7044331512908002; Volume Measure: 0.1617044331512907; Area Measure: 22.4921273981363505

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 161.7044331512908002; Volume Measure: 0.1617044331512907; Area Measure: 22.4921273981363505

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 161.7044331512908002; Volume Measure: 0.1617044331512907; Area Measure: 22.4921273981363505

# IfcBuildingElementProxy (161)
In: default BuildingStorey
Name
EBL-EKF-F-2424-24-30-000 FIN-FLOW + EKKO CEILING FIXING ASSEMBLY | PSet_Mass_Property - Mass Measure: 161.7044331512908002; Volume Measure: 0.1617044331512907; Area Measure: 22.4921273981363505
F000264 P50 SUSPENSION FITTING.SLDPRT
20 x F000264 P50 Clutch Fitting
20 x F000264 P50 Tensile Steel Wire 2m
20 x F000264 P50 M5 Threaded Bolt
20 x F000264 P50 Top Threaded Insert
ACF SUSRAIL - PRIMARY SECONDARY
EBL-EKF-F-2424-24-30-000 FIN-FLOW + ACF SUSRAIL PRIMARY WIDE
14 x ACF SUSRAIL - PRIMARY - WIDE
14 x EBL-EKF-F-2424-24-30-000 FIN-FLOW
PRIMARY TO SECONDARY CONNECTOR
F000264 P50 SUSPENSION FITTING.SLDPRT-1
F000264 P50 SUSPENSION FITTING.SLDPRT-2
EBL-EKF-F-2424-24-30-000 FIN-FLOW + ACF SUSRAIL PRIMARY WIDE-1
F000264 P50 SUSPENSION FITTING.SLDPRT-3
F000264 P50 SUSPENSION FITTING.SLDPRT-4
ACF SUSRAIL - PRIMARY SECONDARY-1
F000264 P50 SUSPENSION FITTING.SLDPRT-5
F000264 P50 SUSPENSION FITTING.SLDPRT-6
ACF SUSRAIL - PRIMARY SECONDARY-2
ACF SUSRAIL - PRIMARY SECONDARY-3
F000264 P50 SUSPENSION FITTING.SLDPRT-7
F000264 P50 SUSPENSION FITTING.SLDPRT-8
PRIMARY TO SECONDARY CONNECTOR-1
EBL-EKF-F-2424-24-30-000 FIN-FLOW + ACF SUSRAIL PRIMARY WIDE-2
EBL-EKF-F-2424-24-30-000 FIN-FLOW + ACF SUSRAIL PRIMARY WIDE-3
EBL-EKF-F-2424-24-30-000 FIN-FLOW + ACF SUSRAIL PRIMARY WIDE-4
EBL-EKF-F-2424-24-30-000 FIN-FLOW + ACF SUSRAIL PRIMARY WIDE-5
EBL-EKF-F-2424-24-30-000 FIN-FLOW + ACF SUSRAIL PRIMARY WIDE-6
EBL-EKF-F-2424-24-30-000 FIN-FLOW + ACF SUSRAIL PRIMARY WIDE-7
EBL-EKF-F-2424-24-30-000 FIN-FLOW + ACF SUSRAIL PRIMARY WIDE-8
EBL-EKF-F-2424-24-30-000 FIN-FLOW + ACF SUSRAIL PRIMARY WIDE-9
EBL-EKF-F-2424-24-30-000 FIN-FLOW + ACF SUSRAIL PRIMARY WIDE-10
EBL-EKF-F-2424-24-30-000 FIN-FLOW + ACF SUSRAIL PRIMARY WIDE-11
EBL-EKF-F-2424-24-30-000 FIN-FLOW + ACF SUSRAIL PRIMARY WIDE-12
EBL-EKF-F-2424-24-30-000 FIN-FLOW + ACF SUSRAIL PRIMARY WIDE-13
PRIMARY TO SECONDARY CONNECTOR-2
PRIMARY TO SECONDARY CONNECTOR-3
PRIMARY TO SECONDARY CONNECTOR-4
PRIMARY TO SECONDARY CONNECTOR-5
PRIMARY TO SECONDARY CONNECTOR-6
PRIMARY TO SECONDARY CONNECTOR-7
PRIMARY TO SECONDARY CONNECTOR-8
PRIMARY TO SECONDARY CONNECTOR-9
PRIMARY TO SECONDARY CONNECTOR-10
PRIMARY TO SECONDARY CONNECTOR-11
PRIMARY TO SECONDARY CONNECTOR-12
F000264 P50 SUSPENSION FITTING.SLDPRT-9
PRIMARY TO SECONDARY CONNECTOR-13
F000264 P50 SUSPENSION FITTING.SLDPRT-10
F000264 P50 SUSPENSION FITTING.SLDPRT-11
F000264 P50 SUSPENSION FITTING.SLDPRT-12
F000264 P50 SUSPENSION FITTING.SLDPRT-13
F000264 P50 SUSPENSION FITTING.SLDPRT-14
F000264 P50 SUSPENSION FITTING.SLDPRT-15
F000264 P50 SUSPENSION FITTING.SLDPRT-16
F000264 P50 SUSPENSION FITTING.SLDPRT-17
F000264 P50 SUSPENSION FITTING.SLDPRT-18
F000264 P50 SUSPENSION FITTING.SLDPRT-19
