Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Fin - Flow\EBL-EKF-F-2424-12-30-000 FIN-FLOW + EKKO CEILING FIXING ASSEMBLY.IFC
Time: 2024-12-18T17:25:02+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 83.3407352352445088; Volume Measure: 0.0833407352352445; Area Measure: 20.6806551785147903

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 83.3407352352445088; Volume Measure: 0.0833407352352445; Area Measure: 20.6806551785147903

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 83.3407352352445088; Volume Measure: 0.0833407352352445; Area Measure: 20.6806551785147903

# IfcBuildingElementProxy (161)
In: default BuildingStorey
Name
EBL-EKF-F-2424-12-30-000 FIN-FLOW + EKKO CEILING FIXING ASSEMBLY | PSet_Mass_Property - Mass Measure: 83.3407352352445088; Volume Measure: 0.0833407352352445; Area Measure: 20.6806551785147903
EBL-EKF-F-2424-12-30-000 FIN-FLOW + ACF SUSRAIL PRIMARY
14 x ACF SUSRAIL - PRIMARY
14 x EBL-EKF-F-2424-12-30-000 FIN-FLOW
PRIMARY TO SECONDARY CONNECTOR
ACF SUSRAIL - PRIMARY SECONDARY
F000264 P50 SUSPENSION FITTING.SLDPRT
20 x F000264 P50 Clutch Fitting
20 x F000264 P50 Tensile Steel Wire 2m
20 x F000264 P50 M5 Threaded Bolt
20 x F000264 P50 Top Threaded Insert
F000264 P50 SUSPENSION FITTING.SLDPRT-1
F000264 P50 SUSPENSION FITTING.SLDPRT-2
F000264 P50 SUSPENSION FITTING.SLDPRT-3
F000264 P50 SUSPENSION FITTING.SLDPRT-4
F000264 P50 SUSPENSION FITTING.SLDPRT-5
F000264 P50 SUSPENSION FITTING.SLDPRT-6
F000264 P50 SUSPENSION FITTING.SLDPRT-7
F000264 P50 SUSPENSION FITTING.SLDPRT-8
F000264 P50 SUSPENSION FITTING.SLDPRT-9
F000264 P50 SUSPENSION FITTING.SLDPRT-10
F000264 P50 SUSPENSION FITTING.SLDPRT-11
F000264 P50 SUSPENSION FITTING.SLDPRT-12
F000264 P50 SUSPENSION FITTING.SLDPRT-13
ACF SUSRAIL - PRIMARY SECONDARY-1
F000264 P50 SUSPENSION FITTING.SLDPRT-14
F000264 P50 SUSPENSION FITTING.SLDPRT-15
EBL-EKF-F-2424-12-30-000 FIN-FLOW + ACF SUSRAIL PRIMARY-1
PRIMARY TO SECONDARY CONNECTOR-1
EBL-EKF-F-2424-12-30-000 FIN-FLOW + ACF SUSRAIL PRIMARY-2
ACF SUSRAIL - PRIMARY SECONDARY-2
ACF SUSRAIL - PRIMARY SECONDARY-3
F000264 P50 SUSPENSION FITTING.SLDPRT-16
F000264 P50 SUSPENSION FITTING.SLDPRT-17
F000264 P50 SUSPENSION FITTING.SLDPRT-18
EBL-EKF-F-2424-12-30-000 FIN-FLOW + ACF SUSRAIL PRIMARY-3
EBL-EKF-F-2424-12-30-000 FIN-FLOW + ACF SUSRAIL PRIMARY-4
EBL-EKF-F-2424-12-30-000 FIN-FLOW + ACF SUSRAIL PRIMARY-5
EBL-EKF-F-2424-12-30-000 FIN-FLOW + ACF SUSRAIL PRIMARY-6
EBL-EKF-F-2424-12-30-000 FIN-FLOW + ACF SUSRAIL PRIMARY-7
EBL-EKF-F-2424-12-30-000 FIN-FLOW + ACF SUSRAIL PRIMARY-8
EBL-EKF-F-2424-12-30-000 FIN-FLOW + ACF SUSRAIL PRIMARY-9
EBL-EKF-F-2424-12-30-000 FIN-FLOW + ACF SUSRAIL PRIMARY-10
EBL-EKF-F-2424-12-30-000 FIN-FLOW + ACF SUSRAIL PRIMARY-11
EBL-EKF-F-2424-12-30-000 FIN-FLOW + ACF SUSRAIL PRIMARY-12
EBL-EKF-F-2424-12-30-000 FIN-FLOW + ACF SUSRAIL PRIMARY-13
PRIMARY TO SECONDARY CONNECTOR-2
PRIMARY TO SECONDARY CONNECTOR-3
PRIMARY TO SECONDARY CONNECTOR-4
PRIMARY TO SECONDARY CONNECTOR-5
PRIMARY TO SECONDARY CONNECTOR-6
PRIMARY TO SECONDARY CONNECTOR-7
PRIMARY TO SECONDARY CONNECTOR-8
PRIMARY TO SECONDARY CONNECTOR-9
PRIMARY TO SECONDARY CONNECTOR-10
PRIMARY TO SECONDARY CONNECTOR-11
PRIMARY TO SECONDARY CONNECTOR-12
PRIMARY TO SECONDARY CONNECTOR-13
F000264 P50 SUSPENSION FITTING.SLDPRT-19
